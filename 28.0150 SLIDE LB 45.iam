# Autodesk Inventor assembly: 28.0150 SLIDE LB 45
## iProperties
Created: 2007-06
Part Number: 28.0150 SLIDE LB 45
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
